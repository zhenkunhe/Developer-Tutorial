RAM_LOAD 0x00000000 0x1000000
{
    RAM_RUN 0x00000000 0x1000000
    {
        ex_3.o	(Init, +First)
        *	(+RO, +RW, +ZI)
    }
}
