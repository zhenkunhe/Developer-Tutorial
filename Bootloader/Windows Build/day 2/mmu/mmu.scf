RAM_LOAD 0x0 0x20000
{
    RAM_RUN 0x0 0x20000
    {
        boot.o	(Setup, +First)
        *		(+RO, +RW, +ZI)
    }
}
